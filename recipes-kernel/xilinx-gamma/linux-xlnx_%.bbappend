FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://xilinx-gamma.cfg"
