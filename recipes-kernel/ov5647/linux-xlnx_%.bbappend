FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://ov5647.cfg"
